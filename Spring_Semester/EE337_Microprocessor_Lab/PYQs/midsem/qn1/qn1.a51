ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL CHECK_LEAP
HERE: SJMP HERE
ORG 130H
// *******
CHECK_LEAP:
MOV A, 30h
MOV B, #04H
DIV AB
MOV A,B
CJNE A,#00h, NOT_LEAP

MOV A, 30h
MOV B, #64H
DIV AB
MOV A,B
JZ NOT_LEAP
LEAP:
MOV 31H, #01H ; Leap year
RET
NOT_LEAP:
MOV 31H, #00H ; Not a leap year
RET
END